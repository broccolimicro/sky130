.include ../pdk/libraries/sky130_fd_pr/xyce/models/corners/ss.spice
