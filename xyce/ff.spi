.include ../pdk/libraries/sky130_fd_pr/xyce_latest/models/corners/ff.spice
